# Keil uVision project modbus.uvproj, settings and files
target modbus (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: modbus +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Source\CORE_LIB_INC;.\Source\BSP;.\Source\;.\Source\App;.\Source\Modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE_LIB_SRC
    ./Source/CORE_LIB_SRC/: stm32f10x_rcc.c stm32f10x_usart.c core_cm3.c system_stm32f10x.c stm32f10x_gpio.c misc.c stm32f10x_exti.c
    ./Source/: STM32F10x.s
  group bsp
    ./Source/BSP/: sys_tick.c usart.c
  group app
    ./Source/: main.c
  group modbus
    ./Source/Modbus/: modbus_rtu.c modbus.c modbus_timer.c modbus_event.c modbus_hook.c modbus_func_coils.c modbus_func_register.c
    ./source/modbus/: modbus_func_custom.c modbus_crc16.c modbus_porting.c
